<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\gr_50.ewp</path>
    </project>
    <batchBuild />
</workspace>
